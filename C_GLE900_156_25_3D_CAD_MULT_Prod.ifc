Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:28:55
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:28:55 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{A0A95A76-C5A5-453A-B3EC-85E0D1163710}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:28:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:28:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:28:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Normal Holes\RFA 3D\GLE900_156_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1; Line Pattern: -3000010

# IfcBuildingElementProxy: GLE900_156_25, GLE900_156_25:GLE900_156_25:132674
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0070796 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/156/2.5
Identity Data - ObjectType: GLE900/156/2.5; URL: www.strongtie.eu; Name: GLE900/156/2.5; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; Model ID: 0338054267256364225183278042239561766123; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14; Model: GLE900/156/2.5; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie; Description: Joist hanger; UniClass Number: Pr_20_29_31_44
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE900/156/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.59
Materials and Finishes - Product Material: Galvanised

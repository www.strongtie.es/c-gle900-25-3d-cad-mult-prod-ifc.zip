Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:28:15
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:28:15 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{FEFA581A-2559-4F78-B947-93B82013B7AD}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:28:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:28:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:28:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Normal Holes\RFA 3D\GLE900_44_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Line Pattern: -3000010

# IfcBuildingElementProxy: GLE900_44_25, GLE900_44_25:GLE900_44_25:97506
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0070796 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/44/2.5
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE900/44/2.5; Name: GLE900/44/2.5; ObjectType: GLE900/44/2.5; UniClass Title: Joist hangers; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0338054267256364225183278042239561766123; UniClass Number: Pr_20_29_31_44; Description: Joist hanger
General - Reference: GLE900/44/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.59; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised

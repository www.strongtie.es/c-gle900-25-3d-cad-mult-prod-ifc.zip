Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:28:23
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:28:23 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{9831EF0C-766D-4324-8197-E2E98B95EB17}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:28:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:28:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:28:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Normal Holes\RFA 3D\GLE900_68_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GLE900_68_25, GLE900_68_25:GLE900_68_25:105042
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0070796 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/68/2.5
Identity Data - UniClass Number: Pr_20_29_31_44; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Model ID: 0338054267256364225183278042239561766123; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Description: Joist hanger; Name: GLE900/68/2.5; ObjectType: GLE900/68/2.5; Model: GLE900/68/2.5; Product Type: Joist hanger; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE900/68/2.5; Density: 1.59; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised

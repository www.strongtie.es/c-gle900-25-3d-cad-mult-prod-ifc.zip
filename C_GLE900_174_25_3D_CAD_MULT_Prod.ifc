Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-23T16:29:01
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 23 16:29:01 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C24B8979-49C0-40DD-926B-9DD0E5992E59}\ifc * Database version: 5507 * Database creation date: Mon Oct 23 16:29:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 23 16:29:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 23 16:29:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 3 - 210 Models\Normal Holes\RFA 3D\GLE900_174_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Line Weight: 1; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GLE900_174_25, GLE900_174_25:GLE900_174_25:138326
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.0070817 ft3
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE900/174/2.5
General - Density: 1.59; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE900/174/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Manufacturer: Simpson Strong-Tie; Description: Joist hanger; Model: GLE900/174/2.5; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Name: GLE900/174/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; URL: www.strongtie.eu; Model ID: 0057101673666581900519327589410759300403; ObjectType: GLE900/174/2.5; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com
Materials and Finishes - Product Material: Galvanised
